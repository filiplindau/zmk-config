## boards/shields/aurora_sweep_dongle/Kconfig.shield
```kconfig
config SHIELD_AURORA_SWEEP_DONGLE
    def_bool $(shields_list_contains,aurora_sweep_dongle)
```
